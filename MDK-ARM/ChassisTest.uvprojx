# Keil uVision project ChassisTest.uvprojx, settings and files
target ChassisTest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ChassisTest +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\IMCALib\Tool;..\IMCALib\Task;..\IMCALib\Module;..\IMCALib\Module\APPInteraction;..\IMCALib\Module\DSP;..\IMCALib\Module\DSP\Include;..\IMCALib\Module\IMU_IIC;..\IMCALib\Tool\judge-driver;..\IMCALib\Tool\PC_connection
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Task
    ../IMCALib/Task/: CanBus_Task.c pid.c RC_Task.c ChassisControl.c ControlTask.c CatchingTask.c GimbalControl.c ShootControl.c
  group Tool
    ../IMCALib/Tool/: Ano_Dt.c PrintfInfo.c user_lib.c ramp.c Kalman.c SW_Wave.c Paraminit.c
    ../IMCALib/Tool/judge-driver/: Driver_Judge.c
    ../IMCALib/Tool/PC_connection/: Judge_interact.c Vision_interact.c
  group Module
    ../IMCALib/Module/APPInteraction/: APPInteraction.c usmart.c usmart_config.c usmart_str.c
    ../IMCALib/Module/DSP/: arm_cortexM4lf_math.lib
    ../IMCALib/Module/IMU_IIC/: IMU_Task.c IOI2C.c
software components: CMSIS:CORE 4.3.0
